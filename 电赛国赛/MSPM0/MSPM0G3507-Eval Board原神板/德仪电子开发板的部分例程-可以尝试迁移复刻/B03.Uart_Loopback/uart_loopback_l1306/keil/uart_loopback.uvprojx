# Keil uVision project uart_loopback.uvprojx, settings and files
target uart_loopback (6160000::V6.16::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_loopback +hex
  BeforeMake: cmd.exe /C "$P../../../tools/keil/syscfg.bat '$P' uart_loopback.syscfg"
  AfterMake: cmd.exe /C "$P../../../tools/keil/gentxt.bat '$P' uart_loopback"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: C:\ti\mspm0_sdk_1_20_01_06/source/third_party/CMSIS/Core/Include;C:\ti\mspm0_sdk_1_20_01_06\source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../: uart_loopback.c printf.c uart_loopback.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l130x_uvision.s
  group Driverlib
    C:/ti/mspm0_sdk_1_20_01_06/source/ti/driverlib/lib/keil/m0p/mspm0l11xx_l13xx/: driverlib.a
