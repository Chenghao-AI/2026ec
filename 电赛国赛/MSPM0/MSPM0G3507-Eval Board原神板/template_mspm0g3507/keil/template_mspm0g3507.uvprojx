# Keil uVision project template_mspm0g3507.uvprojx, settings and files
target template_mspm0g3507 (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template_mspm0g3507
  BeforeMake: cmd.exe /C "C:\ti\mspm0_sdk_2_01_00_03\tools\keil\syscfg.bat '$P' template_mspm0g3507.syscfg"
  AfterMake: cmd.exe /C "C:\ti\gentxt\gentxt.bat '$P' template_mspm0g3507"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_01_00_03\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ./: startup_mspm0g350x_uvision.s
    ../: template_mspm0g3507.c template_mspm0g3507.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
  group Driverlib
    C:/ti/mspm0_sdk_2_01_00_03/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
