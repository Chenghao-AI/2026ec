# Keil uVision project uart_loopback.uvprojx, settings and files
target uart_loopback (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_loopback +hex
  BeforeMake: cmd.exe /C "$P../../../tools/keil/syscfg.bat '$P' uart_loopback.syscfg"
  AfterMake: cmd.exe /C "$P../../../tools/keil/gentxt.bat '$P' uart_loopback"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_1_20_01_06/source/third_party/CMSIS/Core/Include;C:\ti\mspm0_sdk_1_20_01_06\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ./: startup_mspm0g350x_uvision.s
    ../: ti_msp_dl_config.h ti_msp_dl_config.c uart_loopback.c uart_loopback.syscfg printf.c
  group Driverlib
    C:/ti/mspm0_sdk_1_20_01_06/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
